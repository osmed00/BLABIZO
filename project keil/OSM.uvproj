# Keil uVision project OSM.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: OSM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    E:/Autosar/IDE and Tools/LCD/: startup_rvmdk.S
    ./: main.c GPIO_CFG.c Bfx.c Bfx.h Std_Types.h GPIO_CFG.h GPIO.c GPIO.h utils.c utils.h
